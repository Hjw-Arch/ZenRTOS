# Keil uVision project CLI.uvprojx, settings and files
target CLI (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: CLI +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,NDEBUG
  c include: ..\CLI & Monitor;..\CORE;..\Drivers\Include;..\FWLIB\inc;..\RTOS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../RTOS/: application.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_rng.c
  group DRIVERS
    ../Drivers/: button.c exevent.c exio.c intertemperature.c light.c rng.c uart.c lcd.c
  group CLI & MONITOR
    ../CLI & Monitor/: cli.c monitor.c
  group ZenRTOS
    ../RTOS/Source/: bitmap.c lock.c main.c rt_cpu.c rt_eflaggroup.c rt_event.c rt_hooks.c rt_idletask.c rt_list.c rt_mailbox.c rt_memblock.c rt_mutex.c rt_task.c rt_time.c rt_timer.c semaphore.c switch.c
